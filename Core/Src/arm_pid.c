/**
  ******************************************************************************
  * @file    arm_pid.c
  * @brief   位置式 PID：P/I/D + 前馈 + 死区 + 抗饱和 + D 一阶低通
  ******************************************************************************
  *
  * @note    ★ 骨架版：代码写好了，注释留空等你填。
  *
  *          每个 `TODO(n)` 后面是一个**问题**。用你自己的话答在 `答：` 下面，
  *          然后把 `TODO(n)` 那行删掉。答不上来就空着，别抄。
  *          带完整注释的参考版在 `elec_control\pid_参考版\`。
  *
  * @note    本文件里的五个大块，就是答辩会被问的五件事：
  *
  *              ① 死区     ② 积分     ③ 微分     ④ 求和     ⑤ 限幅+抗饱和
  *
  ******************************************************************************
  */

/* TODO(1) 为什么这一行下面**没有**别的 include？多加一个 arm_cfg.h 会怎样？
 *
 * 答：
 */
#include "arm_pid.h"

/* ------------------------------------------------------------------------- */
/* 绝对值                                                                      */
/*                                                                            */
/* TODO(2) 为什么不直接用 <math.h> 的 fabsf？                                  */
/*         （提示：这个模块的卖点是什么？PC 单测是怎么编的？）                  */
/*                                                                            */
/* 答：                                                                        */
/* ------------------------------------------------------------------------- */
static float fabs_f(float x)
{
  return (x < 0.0f) ? -x : x;
}

/* ------------------------------------------------------------------------- */
/* 限幅：把 *v 夹进 [-lim, +lim]                                              */
/*                                                                            */
/* TODO(3) 参数为什么是 `float *v` 而不是 `float v`？                           */
/*         返回值 hit 是给谁用的？                                             */
/*                                                                            */
/* 答：                                                                        */
/* ------------------------------------------------------------------------- */
static uint8_t clamp_f(float *v, float lim)
{
  uint8_t hit = 0u;

  if (*v > lim)
  {
    *v  = lim;
    hit = 1u;
  }
  else if (*v < -lim)
  {
    *v  = -lim;
    hit = 1u;
  }

  return hit;
}

/* ========================================================================== */
/* 对外                                                                        */
/* ========================================================================== */

/* 清状态。
 *
 * TODO(4) 注意它清了 integ/prev_meas/d_state/started/sat，**没清** kp/ki。
 *         为什么？
 *
 * 答：参数固定，除非环境改变
 */
void arm_pid_reset(arm_pid_t *p)/*#复位函数#*/
{
  if (p == 0)
  {
    return;
  }

  p->integ     = 0.0f;/*#清空积分项#*/
  p->prev_meas = 0.0f;
  p->d_state   = 0.0f;
  p->started   = 0u;
  p->sat       = 0u;
}

float arm_pid_step(arm_pid_t *p, float err, float meas, float ff)
{
  float   u;
  float   integ_new;
  float   i_term;
  float   d_raw;
  float   d_term;
  uint8_t dead;

  if (p == 0)
  {
    return 0.0f;
  }

  /* ======================= ① 死区 =========================================
   *
   * TODO(5) 死区判定为什么放在**最前面**？旧代码是在最后把 u 清 0，
   *         这两种写法在"只有 P"时等价，加了 I 之后差别在哪？
   *
   * 答：
   *
   * TODO(6) 死区里为什么要把 integ 清 0？为什么还要 prev_meas = meas、
   *         started = 1u（而不是留着旧值）？
   *
   * 答：
   *
   * TODO(7) 死区里直接 return 0，等于**连前馈 ff 也扔了**。
   *         为什么这是对的？（提示：误差小到进死区代表什么？留着前馈会怎样？）
   *
   * 答：
   * ======================================================================= */
  dead = (uint8_t)((p->deadband > 0.0f) && (fabs_f(err) < p->deadband));/*#死区判断#*/

  if (dead != 0u)
  {
    p->integ     = 0.0f;
    p->d_state   = 0.0f;
    p->prev_meas = meas;
    p->started   = 1u;
    p->sat       = 0u;

    return 0.0f;
  }

  /* ======================= ② 积分 =========================================
   *
   * TODO(8) 积分器 integ 里存的是 Σ(e·dt)，**没有**乘 Ki。
   *         为什么不存"已经乘好 Ki 的 µs"？
   *
   * 答：
   *
   * TODO(9) i_max 的单位是 µs（"积分项最多贡献多少 µs"），
   *         为什么限幅时要用 `i_max / |ki|` 去夹 integ？
   *         直接拿 i_max 去夹 integ 会怎样？
   *
   * 答：
   *
   * TODO(10) 这一拍算了新的 integ_new，但**没有立刻写回 p->integ**，
   *          而是等到函数最末尾才写。为什么？（提示：⑤ 的冻结逻辑还要改它）
   *
   * 答：
   * ======================================================================= */
  integ_new = p->integ;
  i_term    = 0.0f;

  if ((p->ki != 0.0f) && (p->dt_s > 0.0f))
  {
    float lim;

    integ_new = p->integ + (err * p->dt_s);

    if (p->i_max > 0.0f)
    {
      lim = p->i_max / ((p->ki > 0.0f) ? p->ki : -p->ki);
      (void)clamp_f(&integ_new, lim);
    }

    i_term = p->ki * integ_new;
  }

  /* ======================= ③ 微分 =========================================
   *
   * TODO(11) 这里算的是 `-(meas - prev_meas) / dt_s`，也就是对**测量值**微分。
   *          如果改成对 err 微分 `(err - prev_err) / dt_s`，会出现什么现象？
   *          setpoint kick 到底是什么？
   *
   * 答：
   *
   * TODO(12) 为什么要加 d_tau_s 这层低通？
   *          算一下：AS5600 是 12 位 / 360°（多少度一个 LSB？），
   *          5ms 一采样，一个 LSB 的跳动在"没滤波的微分"里等于多少 °/s？
   *
   * 答：
   *
   * TODO(13) started == 0 的第一拍为什么要单独处理？
   *          直接算 (meas - 0)/dt_s 会得到什么？
   *
   * 答：
   *
   * TODO(14) 低通那行 `d_state += alpha * (d_raw - d_state)`，
   *          alpha = dt/(tau+dt)。tau 越大，alpha 越__，滤波越__？
   *          代价是什么？
   *
   * 答：
   * ======================================================================= */
  d_term = 0.0f;

  if ((p->kd != 0.0f) && (p->dt_s > 0.0f))
  {
    if (p->started == 0u)
    {
      p->prev_meas = meas;
      d_raw        = 0.0f;
      p->started   = 1u;
    }
    else
    {
      d_raw = -(meas - p->prev_meas) / p->dt_s;

      /* ★ 合理性检查：这一拍的微分是不是"物理上不可能"？
       *
       * meas 在本工程里是会绕回的角度（±180 接缝），跨接缝那一拍会跳 360°，
       * 除以 5ms 就是 72000°/s —— 真·最大转速的 400 倍。不进这道检查的话，
       * 低通把它削到 9% 之后还要 51 拍（255ms）才衰减完，这 255ms 输出一直
       * 顶在限幅上，舵机全速冲（仿真：冲过目标 3.07°）。
       *
       * 处理方式 = "这一帧丢了"：微分置 0、滤波器状态清零。
       * 函数末尾的 prev_meas = meas 照常执行，所以下一拍就从新位置重新算，
       * 只损失 5ms 的微分信息，不会连续丢。 */
      if ((p->d_max > 0.0f) && (fabs_f(d_raw) > p->d_max))
      {
        d_raw      = 0.0f;
        p->d_state = 0.0f;
      }
    }

    if (p->d_tau_s > 0.0f)
    {
      float alpha = p->dt_s / (p->d_tau_s + p->dt_s);
      p->d_state  = p->d_state + (alpha * (d_raw - p->d_state));
    }
    else
    {
      p->d_state = d_raw;
    }

    d_term = p->kd * p->d_state;
  }

  p->prev_meas = meas;

  /* ======================= ④ 求和 =========================================
   *
   * TODO(15) 为什么不写成一行的
   *              u = ff + (kp * err) + i_term + d_term;
   *          而要写成一个加法 + 两个 if？
   *          （提示：浮点加法满足结合律吗？第 1 组测试在比什么？）
   *
   * 答：
   *
   * TODO(16) `u = ff + (p->kp * err);` 这一行，跟 arm_joint.c 里哪一句旧代码
   *          必须逐字一致？为什么括号位置都不能动？
   *
   * 答：
   * ======================================================================= */
  u = ff + (p->kp * err);

  if (p->ki != 0.0f)
  {
    u = u + i_term;
  }

  if (p->kd != 0.0f)
  {
    u = u + d_term;
  }

  /* ======================= ⑤ 限幅 + 抗饱和 ================================
   *
   * TODO(17) 输出已经顶在 out_max 上、误差还在往同一个方向推，
   *          这时候"积分继续涨"会造成什么后果？这个现象叫什么？
   *
   * 答：
   *
   * TODO(18) 这叫"冻结法"：把这一拍的积分增量**丢掉**（integ_new = p->integ）。
   *          为什么是"丢掉增量"而不是"把 integ 清零"？
   *
   * 答：
   *
   * TODO(19) 误差反向了（比如已经过冲）为什么就**不能**冻结？
   *          那时候积分在帮什么忙？
   *
   * 答：
   *
   * TODO(20) 判据用的是 `u >= p->out_max`，而不是 `p->sat == 1`。为什么？
   *
   * 答：
   * ======================================================================= */
  p->sat = 0u;

  if (p->out_max > 0.0f)
  {
    p->sat = clamp_f(&u, p->out_max);/*#输出限幅#*/
  }

  if ((p->ki != 0.0f) && (p->out_max > 0.0f))
  {
    if (((u >= p->out_max) && (err > 0.0f)) ||
        ((u <= -p->out_max) && (err < 0.0f)))
    {
      integ_new = p->integ;
    }
  }

  p->integ = integ_new;

  return u;
}

uint8_t arm_pid_saturated(const arm_pid_t *p)
{
  return (p == 0) ? 0u : p->sat;
}
